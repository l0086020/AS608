# Keil uVision project Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: delay.c main.c Uart.c Key.c Beep.c LCD12864.c AS608.c NVIC.c
